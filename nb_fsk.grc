options:
  parameters:
    generate_options: no_gui
    id: top_block
    output_language: python
    run_options: run
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: broadcast_freq
  id: variable
  parameters:
    value: 540M
  states: {}
- name: max_freq_dev
  id: variable
  parameters:
    value: '4500'
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.141592654'
  states: {}
- name: rf_samp_rate
  id: variable
  parameters:
    value: '8000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: samp_rate / (baud)
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2 * pi * max_freq_dev / samp_rate
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {state: bypassed}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /tmp/pocsag.wav
    repeat: 'False'
  states: {}
- name: osmosdr_sink_0_0
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: broadcast_freq
    gain0: '0'
    if_gain0: '16'
    sample_rate: rf_samp_rate
    sync: none
    type: fc32
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: rf_samp_rate / samp_rate
    type: ccf
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: rf_samp_rate
    fc: '0'
    fftsize: '8192'
    showports: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '1000000'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: broadcast_freq
    samp_rate: rf_samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [analog_frequency_modulator_fc_0, '0', pfb_arb_resampler_xxx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_wavfile_source_0, '0', blocks_add_const_vxx_0, '0']
- [pfb_arb_resampler_xxx_0, '0', osmosdr_sink_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [pfb_arb_resampler_xxx_0, '0', soapy_hackrf_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
